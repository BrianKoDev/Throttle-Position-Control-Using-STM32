# Keil uVision project WSC055 Lab1.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F303VC STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.4.0
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00002000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: WSC055 Lab1
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\..\..\AppData\Local\Arm\Packs\ARM\CMSIS\5.0.1\CMSIS\Include;..\..\..\..\..\AppData\Local\Arm\Packs\Keil\STM32F3xx_DFP\1.4.0\Device\Include;..\..\..\..\AppData\Local\Arm\Packs\ARM\CMSIS\5.0.1\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group Source Group 1
    ./: main.c
  group Include
    ./: system_stm32f3xx.c startup_stm32f303xc.s
